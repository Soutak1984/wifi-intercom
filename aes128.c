#include "ic_crypto.h"

#include <string.h>

static const uint8_t sbox[256] = {
    0x63, 0x7c, 0x77, 0x7b, 0xf2, 0x6b, 0x6f, 0xc5, 0x30, 0x01, 0x67, 0x2b, 0xfe, 0xd7, 0xab, 0x76,
    0xca, 0x82, 0xc9, 0x7d, 0xfa, 0x59, 0x47, 0xf0, 0xad, 0xd4, 0xa2, 0xaf, 0x9c, 0xa4, 0x72, 0xc0,
    0xb7, 0xfd, 0x93, 0x26, 0x36, 0x3f, 0xf7, 0xcc, 0x34, 0xa5, 0xe5, 0xf1, 0x71, 0xd8, 0x31, 0x15,
    0x04, 0xc7, 0x23, 0xc3, 0x18, 0x96, 0x05, 0x9a, 0x07, 0x12, 0x80, 0xe2, 0xeb, 0x27, 0xb2, 0x75,
    0x09, 0x83, 0x2c, 0x1a, 0x1b, 0x6e, 0x5a, 0xa0, 0x52, 0x3b, 0xd6, 0xb3, 0x29, 0xe3, 0x2f, 0x84,
    0x53, 0xd1, 0x00, 0xed, 0x20, 0xfc, 0xb1, 0x5b, 0x6a, 0xcb, 0xbe, 0x39, 0x4a, 0x4c, 0x58, 0xcf,
    0xd0, 0xef, 0xaa, 0xfb, 0x43, 0x4d, 0x33, 0x85, 0x45, 0xf9, 0x02, 0x7f, 0x50, 0x3c, 0x9f, 0xa8,
    0x51, 0xa3, 0x40, 0x8f, 0x92, 0x9d, 0x38, 0xf5, 0xbc, 0xb6, 0xda, 0x21, 0x10, 0xff, 0xf3, 0xd2,
    0xcd, 0x0c, 0x13, 0xec, 0x5f, 0x97, 0x44, 0x17, 0xc4, 0xa7, 0x7e, 0x3d, 0x64, 0x5d, 0x19, 0x73,
    0x60, 0x81, 0x4f, 0xdc, 0x22, 0x2a, 0x90, 0x88, 0x46, 0xee, 0xb8, 0x14, 0xde, 0x5e, 0x0b, 0xdb,
    0xe0, 0x32, 0x3a, 0x0a, 0x49, 0x06, 0x24, 0x5c, 0xc2, 0xd3, 0xac, 0x62, 0x91, 0x95, 0xe4, 0x79,
    0xe7, 0xc8, 0x37, 0x6d, 0x8d, 0xd5, 0x4e, 0xa9, 0x6c, 0x56, 0xf4, 0xea, 0x65, 0x7a, 0xae, 0x08,
    0xba, 0x78, 0x25, 0x2e, 0x1c, 0xa6, 0xb4, 0xc6, 0xe8, 0xdd, 0x74, 0x1f, 0x4b, 0xbd, 0x8b, 0x8a,
    0x70, 0x3e, 0xb5, 0x66, 0x48, 0x03, 0xf6, 0x0e, 0x61, 0x35, 0x57, 0xb9, 0x86, 0xc1, 0x1d, 0x9e,
    0xe1, 0xf8, 0x98, 0x11, 0x69, 0xd9, 0x8e, 0x94, 0x9b, 0x1e, 0x87, 0xe9, 0xce, 0x55, 0x28, 0xdf,
    0x8c, 0xa1, 0x89, 0x0d, 0xbf, 0xe6, 0x42, 0x68, 0x41, 0x99, 0x2d, 0x0f, 0xb0, 0x54, 0xbb, 0x16
};

static const uint8_t Rcon[11] = {
    0x00, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x1b, 0x36
};

static uint8_t xtime(uint8_t x) {
    return (uint8_t)((x << 1) ^ ((x & 0x80) ? 0x1b : 0x00));
}

static void expand_key(const uint8_t key[16], uint8_t rk[176]) {
    int bytes = 16;
    int rcon_i = 1;
    uint8_t t[4];

    memcpy(rk, key, 16);
    while (bytes < 176) {
        memcpy(t, rk + bytes - 4, 4);
        if ((bytes % 16) == 0) {
            uint8_t tmp = t[0];
            t[0] = (uint8_t)(sbox[t[1]] ^ Rcon[rcon_i++]);
            t[1] = sbox[t[2]];
            t[2] = sbox[t[3]];
            t[3] = sbox[tmp];
        }
        for (int i = 0; i < 4; i++) {
            rk[bytes] = (uint8_t)(rk[bytes - 16] ^ t[i]);
            t[i] = rk[bytes];
            bytes++;
        }
    }
}

static void add_round_key(uint8_t s[16], const uint8_t *rk) {
    for (int i = 0; i < 16; i++) {
        s[i] ^= rk[i];
    }
}

static void sub_bytes(uint8_t s[16]) {
    for (int i = 0; i < 16; i++) {
        s[i] = sbox[s[i]];
    }
}

static void shift_rows(uint8_t s[16]) {
    uint8_t t;
    t = s[1];
    s[1] = s[5];
    s[5] = s[9];
    s[9] = s[13];
    s[13] = t;
    t = s[2];
    s[2] = s[10];
    s[10] = t;
    t = s[6];
    s[6] = s[14];
    s[14] = t;
    /* Row 3 rotates left by three, which is a right rotate by one. */
    t = s[15];
    s[15] = s[11];
    s[11] = s[7];
    s[7] = s[3];
    s[3] = t;
}

static void mix_columns(uint8_t s[16]) {
    for (int c = 0; c < 4; c++) {
        uint8_t *p = s + (4 * c);
        uint8_t a0 = p[0];
        uint8_t a1 = p[1];
        uint8_t a2 = p[2];
        uint8_t a3 = p[3];
        p[0] = (uint8_t)(xtime(a0) ^ (uint8_t)(xtime(a1) ^ a1) ^ a2 ^ a3);
        p[1] = (uint8_t)(a0 ^ xtime(a1) ^ (uint8_t)(xtime(a2) ^ a2) ^ a3);
        p[2] = (uint8_t)(a0 ^ a1 ^ xtime(a2) ^ (uint8_t)(xtime(a3) ^ a3));
        p[3] = (uint8_t)((uint8_t)(xtime(a0) ^ a0) ^ a1 ^ a2 ^ xtime(a3));
    }
}

void ic_aes128_encrypt_block(const uint8_t key[16], const uint8_t in[16], uint8_t out[16]) {
    uint8_t rk[176];
    uint8_t s[16];
    int round;

    expand_key(key, rk);
    memcpy(s, in, 16);
    add_round_key(s, rk);
    for (round = 1; round <= 10; round++) {
        sub_bytes(s);
        shift_rows(s);
        if (round != 10) {
            mix_columns(s);
        }
        add_round_key(s, rk + (16 * round));
    }
    memcpy(out, s, 16);
}

static void inc_counter(uint8_t counter[16]) {
    for (int i = 15; i >= 12; i--) {
        counter[i]++;
        if (counter[i] != 0) {
            break;
        }
    }
}

void ic_aes128_ctr(const uint8_t key[16], const uint8_t nonce[16], uint8_t *buf, size_t len) {
    uint8_t counter[16];
    size_t off = 0;

    memcpy(counter, nonce, 16);
    while (off < len) {
        uint8_t stream[16];
        size_t n;
        size_t i;
        ic_aes128_encrypt_block(key, counter, stream);
        n = len - off;
        if (n > 16) {
            n = 16;
        }
        for (i = 0; i < n; i++) {
            buf[off + i] ^= stream[i];
        }
        inc_counter(counter);
        off += n;
    }
}

static int hex_nibble(char c) {
    if (c >= '0' && c <= '9') {
        return c - '0';
    }
    if (c >= 'a' && c <= 'f') {
        return c - 'a' + 10;
    }
    if (c >= 'A' && c <= 'F') {
        return c - 'A' + 10;
    }
    return -1;
}

static int parse_hex(const char *hex, uint8_t *out, size_t out_len) {
    size_t i;
    for (i = 0; i < out_len; i++) {
        int hi = hex_nibble(hex[i * 2]);
        int lo = hex_nibble(hex[i * 2 + 1]);
        if (hi < 0 || lo < 0) {
            return -1;
        }
        out[i] = (uint8_t)((hi << 4) | lo);
    }
    return 0;
}

int ic_crypto_selftest(void) {
    static const char sha_abc[] = "abc";
    static const uint8_t sha_abc_out[32] = {
        0xba, 0x78, 0x16, 0xbf, 0x8f, 0x01, 0xcf, 0xea, 0x41, 0x41, 0x40, 0xde, 0x5d, 0xae, 0x22, 0x23,
        0xb0, 0x03, 0x61, 0xa3, 0x96, 0x17, 0x7a, 0x9c, 0xb4, 0x10, 0xff, 0x61, 0xf2, 0x00, 0x15, 0xad
    };
    static const uint8_t hmac_key[20] = {
        0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b,
        0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b
    };
    static const uint8_t hmac_data[] = {'H', 'i', ' ', 'T', 'h', 'e', 'r', 'e'};
    static const uint8_t hmac_out[32] = {
        0xb0, 0x34, 0x4c, 0x61, 0xd8, 0xdb, 0x38, 0x53, 0x5c, 0xa8, 0xaf, 0xce, 0xaf, 0x0b, 0xf1, 0x2b,
        0x88, 0x1d, 0xc2, 0x00, 0xc9, 0x83, 0x3d, 0xa7, 0x26, 0xe9, 0x37, 0x6c, 0x2e, 0x32, 0xcf, 0xf7
    };
    uint8_t dig[32];
    uint8_t key[16];
    uint8_t pt[16];
    uint8_t ct[16];
    uint8_t expect[16];
    ic_sha256_t ctx;

    ic_sha256_init(&ctx);
    ic_sha256_update(&ctx, (const uint8_t *)sha_abc, 3);
    ic_sha256_final(&ctx, dig);
    if (!ic_ct_equal(dig, sha_abc_out, 32)) {
        return -1;
    }

    ic_hmac_sha256(hmac_key, sizeof(hmac_key), hmac_data, sizeof(hmac_data), dig);
    if (!ic_ct_equal(dig, hmac_out, 32)) {
        return -2;
    }

    if (parse_hex("000102030405060708090a0b0c0d0e0f", key, 16) != 0 ||
        parse_hex("00112233445566778899aabbccddeeff", pt, 16) != 0 ||
        parse_hex("69c4e0d86a7b0430d8cdb78070b4c55a", expect, 16) != 0) {
        return -3;
    }
    ic_aes128_encrypt_block(key, pt, ct);
    if (!ic_ct_equal(ct, expect, 16)) {
        return -4;
    }
    return 0;
}
